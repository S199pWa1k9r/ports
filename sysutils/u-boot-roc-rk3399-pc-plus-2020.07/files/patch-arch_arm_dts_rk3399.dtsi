--- arch/arm/dts/rk3399.dtsi.orig	2020-07-06 22:22:53.000000000 +0300
+++ arch/arm/dts/rk3399.dtsi	2021-03-02 14:03:56.615927000 +0300
@@ -1353,7 +1353,7 @@
 		#clock-cells = <1>;
 		#reset-cells = <1>;
 		assigned-clocks =
-			<&cru PLL_GPLL>, <&cru PLL_CPLL>,
+			<&cru PLL_GPLL>,
 			<&cru PLL_NPLL>,
 			<&cru ACLK_PERIHP>, <&cru HCLK_PERIHP>,
 			<&cru PCLK_PERIHP>,
@@ -1362,9 +1362,9 @@
 			<&cru HCLK_PERILP1>, <&cru PCLK_PERILP1>,
 			<&cru ACLK_VIO>, <&cru ACLK_HDCP>,
 			<&cru ACLK_GIC_PRE>,
-			<&cru PCLK_DDR>;
+			<&cru PCLK_DDR>, <&cru ACLK_VOP1>;
 		assigned-clock-rates =
-			 <594000000>,  <800000000>,
+			 <594000000>,
 			<1000000000>,
 			 <150000000>,   <75000000>,
 			  <37500000>,
@@ -1373,7 +1373,7 @@
 			 <100000000>,   <50000000>,
 			 <400000000>, <400000000>,
 			 <200000000>,
-			 <200000000>;
+			 <200000000>, <594000000>;
 	};
 
 	grf: syscon@ff770000 {
@@ -1604,13 +1604,13 @@
 			#address-cells = <1>;
 			#size-cells = <0>;
 
-			vopl_out_mipi: endpoint@0 {
-				reg = <0>;
+			vopl_out_mipi: endpoint@1 {
+				reg = <1>;
 				remote-endpoint = <&mipi_in_vopl>;
 			};
 
-			vopl_out_edp: endpoint@1 {
-				reg = <1>;
+			vopl_out_edp: endpoint@0 {
+				reg = <0>;
 				remote-endpoint = <&edp_in_vopl>;
 			};
 
