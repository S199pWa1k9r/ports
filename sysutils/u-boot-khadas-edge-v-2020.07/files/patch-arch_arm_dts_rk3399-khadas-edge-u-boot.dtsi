--- arch/arm/dts/rk3399-khadas-edge-u-boot.dtsi.orig	2020-07-06 22:22:53.000000000 +0300
+++ arch/arm/dts/rk3399-khadas-edge-u-boot.dtsi	2021-04-11 05:04:19.708745000 +0300
@@ -8,10 +8,26 @@
 
 / {
 	chosen {
-		u-boot,spl-boot-order = "same-as-spl", &sdhci, &sdmmc;
+		u-boot,spl-boot-order = "same-as-spl", &spiflash, &sdmmc, &sdhci;
 	};
+
+	aliases {
+	    spi0 = &spi1;
+	};
+	
 };
 
 &vdd_log {
 	regulator-init-microvolt = <950000>;
+};
+
+&spi1 {
+	max-freq = <104000000>;
+	status = "okay";
+
+	spiflash: flash@0 {
+		compatible = "winbond,w25q128fw", "jedec,spi-nor";
+		reg = <0>;
+		spi-max-frequency = <104000000>;
+	};
 };
