--- arch/arm/dts/rk3399-rock-pi-4.dts.orig	2021-01-25 10:24:44.146871000 +0300
+++ arch/arm/dts/rk3399-rock-pi-4.dts	2021-01-25 10:25:40.808477000 +0300
@@ -733,3 +733,13 @@
 &vopl_mmu {
 	status = "okay";
 };
+
+&spi1 {
+	status = "okay";
+
+	flash@0 {
+		compatible = "jedec,spi-nor";
+		reg = <0>;
+		spi-max-frequency = <10000000>;
+	};
+};
